KBRANCH ?= "1020-dev-5.15"
LINUX_VERSION ?= "5.15"

SRCREV="5f43ea65ce119ccb3023cde92337106001a7cb31"

require linux-aspeed.inc
