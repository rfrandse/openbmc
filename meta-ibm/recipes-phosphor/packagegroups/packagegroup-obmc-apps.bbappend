RDEPENDS_${PN}-logging += "ibm-logging"
RDEPENDS_${PN}-extras += "nginx sbe-validation"
